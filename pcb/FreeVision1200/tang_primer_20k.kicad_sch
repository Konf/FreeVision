File: pcb/FreeVision1200/tang_primer_20k.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Schematic update
Other:
- note added: "90 3.3V total io 34 data 24 addr 11 other 12 hdmi"
